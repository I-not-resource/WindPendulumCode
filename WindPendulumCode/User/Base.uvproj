# Keil uVision project Base.uvproj, settings and files
target Base (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Base +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\User;..\System;..\System\CORE;..\System\FWLIB\inc;..\System\FWLIB\src;..\System\Sys;..\Software;..\Hardware;..\Software\LCD_SPECIFIC;..\Hardware\eMPL;..\Hardware\MPU9150;..\Hardware\STM32_IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c
  group Hardware
    ../Hardware/: DMA.c Usart.c pwm.c lcd_drive.c ADC.C TIMControl.c Key.c
  group Software
    ../Software/LCD_SPECIFIC/: LCD_OWN.c
    ../Software/: PID.C IRQ_CELL.c display.c run.c datadefine.c
  group System
    ../System/Sys/: stm32f4xx_it.c system_stm32f4xx.c Sys.c
  group FWILB
    ../System/FWLIB/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c misc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_fsmc.c stm32f4xx_adc.c
  group Core
    ../System/CORE/: startup_stm32f40_41xxx.s
  group H_File
    ../System/Sys/: ALL_Config.h stm32f4xx_conf.h
